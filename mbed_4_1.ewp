# IAR project mbed_4_1.ewp, settings and files
configuration mbed_4_1 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; -DTOOLCHAIN_object; --guard_calls; -DDEVICE_SEMIHOST=1; -DFEATURE_LWIP=1; -DDEVICE_SLEEP=1; -DTARGET_LPC1768; -DTARGET_RELEASE; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -D__CORTEX_M3; -DDEVICE_PWMOUT=1; -DTARGET_M3; -DDEVICE_CAN=1; -DDEVICE_PORTOUT=1; -DDEVICE_FLASH=1; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DARM_MATH_CM3; -DDEVICE_INTERRUPTIN=1; -DTARGET_LIKE_CORTEX_M3; -DDEVICE_SERIAL=1; -DDEVICE_ANALOGIN=1; -DDEVICE_PORTIN=1; -DTARGET_CORTEX_M; -DDEVICE_ETHERNET=1; -DDEVICE_I2C=1; --preinclude=mbed_config.h; -DDEVICE_DEBUG_AWARENESS=1; -DTARGET_UVISOR_UNSUPPORTED; --no_wrap_diagnostics; -DTARGET_LPCTarget; -DTARGET_LIKE_MBED; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DDEVICE_SPISLAVE=1; -DDEVICE_SERIAL_FC=1; -DDEVICE_LOCALFILESYSTEM=1; -DMBED_BUILD_TIMESTAMP=1523923211.44; -DTARGET_LPC176X; -DTARGET_CORTEX; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -DTARGET_NXP; -DTARGET_MBED_LPC1768; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; HC_SR04_Ultrasonic_Library; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device; mbed/TARGET_LPC1768/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -D__CORTEX_M3; -DARM_MATH_CM3
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_LPC1768/TOOLCHAIN_IAR/LPC17xx.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group HC_SR04_Ultrasonic_Library
    HC_SR04_Ultrasonic_Library/: ultrasonic.h ultrasonic.cpp
  group mbed
    mbed/: mbed.h
    mbed/TARGET_LPC1768/: cmsis_armcc.h arm_math.h core_cmSecureAccess.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: PeripheralNames.h PortNames.h gpio_object.h objects.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: reserved_pins.h PinNames.h device.h
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis_nvic.h LPC17xx.h cmsis.h system_LPC17xx.h
    mbed/drivers/: DigitalInOut.h AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/platform/: CriticalSectionLock.h ATCmdParser.h CThunk.h CallChain.h Callback.h CircularBuffer.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h NonCopyable.h PlatformMutex.h SingletonPtr.h Stream.h Transaction.h critical.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h rtc_time.h semihost_api.h sleep.h toolchain.h wait_api.h
    mbed/TARGET_LPC1768/TOOLCHAIN_IAR/: analogin_api.o CRP.o analogout_api.o can_api.o cmain.o ethernet_api.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed_board.o mbed_retarget.o mbed_sdk_boot.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o system_LPC17xx.o us_ticker.o mbed.a
  group mbed_4_1
    ./: mbed_config.h main.cpp
